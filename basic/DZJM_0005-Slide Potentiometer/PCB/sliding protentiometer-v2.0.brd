# Repository lryain/peak_puzzle

## EAGLE design basic/DZJM_0005-Slide Potentiometer/PCB/sliding protentiometer-v2.0.brd

Parts:
C1, C2: 100nF; 0805
JP1: M0410; JMZY-1X4
LED: GREEN; LED-0805
R1: 10k; 3P-SQUA-45.6X10X5.8H
R2: 1k; 0805
U$3: DZJM-B203; DZJM-B20-3P

Connections:
GND: C1.2, C2.2, JP1.4, LED.-, R1.1
LED: JP1.2, R2.1
unnamed: LED.+, R2.2
OUT: C2.1, JP1.1, R1.2 (3)
VCC: C1.1, JP1.3, R1.3 (2)

Board: 2 copper layers, 60.0 x 24.8 mm, 9 parts (2 on the bottom side), 5 nets.

Other parts of the board:
U$1: BRICK-LOGO-MIL-0.5
U$2: OSHW_FILLX150_NOTEXT

## EAGLE design basic/DZJM_0006-4-Digit Display/PCB/Puzzle_4-Digit Display v2.0.brd

Parts:
C1: 10uF; 0603
C2: 100nF; 0603
C3, C4: 1nF; 0603
J1: TWIG-4P-2.0-SMD-FEMALE-REINFORCE'90D'; 4P-SMD-2.0-90D
R1, R2: 10k; 0603
U1: TM1637; SOP20-10.45
U2: LED-4-BETY-7-SEG; 7-4-BYTE-SEG-2.54-30X14X7.3H
U$1: DZJM-B202; DZJM-B20-2P

Connections:
A: U1.2 (SG1/KS1), U2.11 (A)
A1: U1.15 (GRID1), U2.12 (COM1)
A2: U1.14 (GRID2), U2.9 (COM2)
A3: U1.13 (GRID3), U2.8 (COM3)
A4: U1.12 (GRID4), U2.6 (COM4)
B: U1.3 (SG1/KS2), U2.7 (B)
C: U1.4 (SG1/KS3), U2.4 (C)
CLK: C3.1, J1.1, R1.2, U1.18 (CLK)
D: U1.5 (SG1/KS4), U2.2 (D)
DIO: C4.1, J1.2, R2.2, U1.17 (DIO)
DP: U1.9 (SG1/KS8), U2.3 (DP)
E: U1.6 (SG1/KS5), U2.1 (E)
F: U1.7 (SG1/KS6), U2.10 (F)
G: U1.8 (SG1/KS7), U2.5 (G)
GND: C1.2, C2.2, C3.2, C4.2, J1.4, J1.SS1, J1.SS2, U1.1 (GND)
VCC: C1.1, C2.1, J1.3, R1.1, R2.1, U1.16 (VDD)

Board: 2 copper layers, 42.4 x 24.8 mm, 12 parts (9 on the bottom side), 16 nets.

Other parts of the board:
U$2: BRICK-LOGO-2-B-MIL-0.6
U$12: OSHW_FILLX200_NOTEXT

## EAGLE design basic/DZJM_0007-Chainable RGB LED/PCB/Puzzle Chainable RGB LED.brd

Parts:
ARGB1: LED-ARGB-DIP2.0; ARGB/2.0
C1, C2: 100n; 0603
J1, J2: TWIG_2.0-SMD-FEMALE'DD'; 2.0_1X4DD
LOGO1: LOGO-OSHW-FILLX0100-NT; OSHW_FILLX100_NOTEXT
MARK1, MARK2: PAD-MARK; MARK
R1, R2: 39R; 0603
R3: 24k; 0603
R4: 3.6R; 0603
TWIG1: TWIG-W/O-VIAU1; U1N
U1: P9813-SSOP16; SSOP16

Connections:
+5V: ARGB1.2 (+), C1.2, J1.3, J2.3, R4.2
CIN: J1.1, U1.3 (CIN)
COUT: J2.1, R2.2
DIN: J1.2, U1.2 (DIN)
DOUT: J2.2, R1.2
GND: C1.1, C2.1, J1.4, J1.SS1, J1.SS2, J2.4, J2.SS1, J2.SS2, R3.2, U1.5 (GND)
unnamed: ARGB1.4 (B), U1.8 (B)
unnamed: ARGB1.3 (G), U1.7 (G)
unnamed: ARGB1.1 (R), U1.6 (R)
unnamed: R1.1, U1.15 (DOUT)
unnamed: R2.1, U1.14 (COUT)
unnamed: R3.1, U1.9 (R-EXT)
unnamed: C2.2, U1.11 (VOUT)
VCC: R4.1, U1.10 (VCC)

Board: 2 copper layers, 20.0 x 24.2 mm, 15 parts (2 on the bottom side), 14 nets.

Other parts of the board:
U$2: BRICK-LOGO-MIL-0.2

## EAGLE design basic/DZJM_0008-Circular LED/PCB/Puzzle Circular LED v0.9b.brd

Parts:
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24: LED'1206'; LED-1206
C1, C2: 100nF; C0603
J1: TWIG-4P-2.0-SMD-FEMALE-REINFORCE'90D'; 4P-SMD-2.0-90D
R1, R2, R3, R4, R5, R6: 7.5k_1%; R0603
R7, R8: 1k; R0603
R9: 10k; R0603
U1, U2: MY9221-TSSOP24EP; TSSOP24EP

Connections:
DCKI: J1.1, R7.1
DCKI1: R7.2, U1.11 (DCKI)
DCKO: U1.12 (DCKO), U2.11 (DCKI)
DI: J1.2, R8.1
DI1: R8.2, U1.13 (DI)
DI2: U1.14 (DO), U2.13 (DI)
GCK0: U1.15 (GCKO), U2.10 (GCKI)
GCKI1: R9.2, U1.10 (GCKI)
GND: C1.2, C2.2, J1.4, J1.SS1, J1.SS2, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R9.1, U1.24 (GND), U1.EP, U2.24 (GND), U2.EP
LED-1: 1.-, U1.21 (OUTA[3])
LED-2: 2.-, U1.20 (OUTB[3])
LED-3: 3.-, U1.19 (OUTC[3])
LED-4: 4.-, U1.18 (OUTA[2])
LED-5: 5.-, U1.17 (OUTB[2])
LED-6: 6.-, U1.16 (OUTC[2])
LED-7: 7.-, U1.9 (OUTA[1])
LED-8: 8.-, U1.8 (OUTB[1])
LED-9: 9.-, U1.7 (OUTC[1])
LED-10: 10.-, U1.6 (OUTA[0])
LED-11: 11.-, U1.5 (OUTB[0])
LED-12: 12.-, U1.4 (OUTC[0])
LED-13: 13.-, U2.21 (OUTA[3])
LED-14: 14.-, U2.20 (OUTB[3])
LED-15: 15.-, U2.19 (OUTC[3])
LED-16: 16.-, U2.18 (OUTA[2])
LED-17: 17.-, U2.17 (OUTB[2])
LED-18: 18.-, U2.16 (OUTC[2])
LED-19: 19.-, U2.9 (OUTA[1])
LED-20: 20.-, U2.8 (OUTB[1])
LED-21: 21.-, U2.7 (OUTC[1])
LED-22: 22.-, U2.6 (OUTA[0])
LED-23: 23.-, U2.5 (OUTB[0])
LED-24: 24.-, U2.4 (OUTC[0])
unnamed: R1.1, U2.1 (REXT-C)
unnamed: R2.1, U2.2 (REXT-B)
unnamed: R4.1, U1.1 (REXT-C)
unnamed: R5.1, U1.2 (REXT-B)
unnamed: R6.1, U1.3 (REXT-A)
unnamed: R3.1, U2.3 (REXT-A)
VCC: 1.+, 2.+, 3.+, 4.+, 5.+, 6.+, 7.+, 8.+, 9.+, 10.+, 11.+, 12.+, 13.+, 14.+, 15.+, 16.+, 17.+, 18.+, 19.+, 20.+, 21.+, 22.+, 23.+, 24.+, C1.1, C2.1, J1.3, U1.23 (VDD), U2.23 (VDD)

Board: 2 copper layers, 45.0 x 45.0 mm, 41 parts (16 on the bottom side), 40 nets.

Other parts of the board:
U$1: BRICK-LOGO-2-B-MIL-0.6
U$2: 1U-DIM-W/-DRILL-SILK
U$4: OSHW_FILLX200_NOTEXT

## EAGLE design basic/DZJM_0009-Collision Sensor/PCB/Puzzle - Collision Sensor V0.9b.brd

Parts:
C1: 10n; 0603
C2: 220p; 0603
D1, D2: D1N4148-SMD; DO-35-SMD
J1: TWIG-4P-2.0-SMD-FEMALE-REINFORCE'DD'; 4P-SMD-2.0
LOGO1: LOGO-OSHW-6MILX0200-NT; OSHW_6X200_NOTEXT
P1, P2: PAD-MARK; ROUND-MARK-0.635
Q1: TRANSISTOR-NPN-SOT23''; SOT23
R1: 10k; 0603
R2: 150; 0603
R3, R4: 100K; 0603
S1: SENSOR-COLLISION; 2P-ROUND-D5.4MM
U1: TWIG-1U; 1U-DIM-W/-DRILL

Connections:
GND: C1.1, D1.A (+), D2.A (+), J1.4, J1.SS2, Q1.2 (E), R3.2, R4.2
unnamed: C2.2, R2.1, S1.1
unnamed: C2.1, D1.C (-), R1.2, R3.1
unnamed: Q1.1 (B), R1.1
NC: J1.2
SIG: C1.2, D2.C (-), J1.1, Q1.3 (C), R2.2, R4.1
VCC: J1.3, S1.2

Board: 2 copper layers, 20.0 x 24.2 mm, 16 parts (14 on the bottom side), 6 nets.

Other parts of the board:
U$1: BRICK-LOGO-MIL-0.6

## EAGLE design basic/DZJM_0010-Digital Light Sensor/PCB/Puzzle Digital light sensor v0.9b.brd

Parts:
C1, C2: 1uF; C0603
C3: 100nF; C0603
J1: Grove; 4P-2.0
Q1, Q2: BSN20; SOT23
R1, R2, R3, R4: 10K; R0603
U1: TSL2561; TMB-6
U3: XC6206MR; SOT23

Connections:
3.3V: C2.2, C3.2, Q1.1 (G), Q2.1 (G), R1.2, R2.2, U1.1 (VDD), U3.2 (VOUT)
5V: C1.2, J1.3, R3.2, R4.2, U3.3 (VIN)
GND: C1.1, C2.1, C3.1, J1.4, U1.2 (ADDR), U1.3 (GND), U3.1 (VSS)
SCL: J1.1, Q2.3 (D), R3.1
SDA: J1.2, Q1.3 (D), R4.1
T_SCL: Q2.2 (S), R2.1, U1.4 (SCL)
T_SDA: Q1.2 (S), R1.1, U1.6 (SDA)

Notes on the sheet:
稳压电路
逻辑电平转换电路

Board: 2 copper layers, 20.0 x 24.2 mm, 15 parts (1 on the bottom side), 7 nets.

Other parts of the board:
U$2: 1U-DIM-W/-DRILL
U$4: OSHW_FILLX200_NOTEXT
U$5: BRICK-LOGO-2-B-MIL-0.6

## EAGLE design basic/DZJM_0011-Encoder/PCB/Puzzle-Encoder v0.9b.brd

Board: 2 copper layers, 24.2 x 20.0 mm, 11 parts (7 on the bottom side), 7 nets.

Parts:
C1: 100nF; C0603
J2: 4P-SMD-2.0
R1, R2, R3, R4, R5: 3.3k; R0603
U1: Encoder; 5P-13.75X11.7X6.5H
U2: 1U-DIM-W/-DRILL
U$1: BRICK-LOGO-MIL-0.5
U$2: OSHW_FILLX150_NOTEXT

Connections:
GND: C1.1, J2.4, J2.SS1, J2.SS2, U1.2, U1.4
SA: R1.2, R3.2, R5.2, U1.1
SB: R2.2, R4.2, U1.3
SIGA: J2.1, R1.1
SIGB: J2.2, R2.1
SW: R5.1, U1.5
VCC: C1.2, J2.3, R3.1, R4.1
